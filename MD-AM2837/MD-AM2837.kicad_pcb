# Repository autome-workspace/tsuguta

File README.md:

# tsugutaのリポジトリ

## KiCadファイル
- MD-AM2837
  - AM2837を使ったシンプルなモタドラ。定格13.5V3.5A(peak 6A)。絶対最大定格15V
- MD-IR2302
  - IR2302を使ったモタドラ。FETにはTOSHIBA製TK7R4A10PL(絶対最大定格100V50A)を使用予定。
- lipo-S.V.-simple-v2
  - li-poバッテリー用の電源電圧監視・保護回路第2版。定格24V35A。各セルの電圧は監視していないため、ほんとは良くない。あくまで簡易版
- my-lib
  - 作る価値のある部品だけ
   
## 【試験運用中】tagについて
- v.x.y
  - x: 0は試作中で動作保証なし、1以降は動く物。1以降では物理的・プログラム的に重大な変更(コネクタ変更、真理値表変更)の場合などに上げる。
  - y: 小さな変更の場合はこちらを上げていく。

## KiCad design MD-AM2837/MD-AM2837.kicad_pcb

Parts:
C1: 220; C_Radial_D8.0mm_H11.5mm_P3.50mm
C2, C3, C4, C5: 0.1; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: SS14; D_SMA
J1: XT60_Male_Horizontal; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: XT60_Female_Horizontal; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J3: Conn_01x03_Pin_signal; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
LED1: INA; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED2: INB; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED3, LED4: PWR; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
MD1: AM2837; SOP-8_3.9x4.9mm_P1.27mm
Q1, Q2: BSS138; SOT-23
R1, R2, R3, R4, R7, R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2: TLP2745; SO-6L_10x3.84mm_P1.27mm

Connections:
GND: C1.2, C2.1, C4.2, C5.2, J1.1 (GND), MD1.3 (GND), Q1.2 (S), Q2.2 (S), R3.2, R4.2, R5.2, R6.2, U1.4 (GND), U2.4 (GND)
GNDS: J3.3, U1.3 (K), U2.3 (K)
IN_A_1: J3.1, R8.1
IN_A_2: MD1.1 (IN_A), R7.1, U1.5 (VO)
IN_B_1: J3.2, R9.1
IN_B_2: MD1.2 (IN_B), R10.1, U2.5 (VO)
unnamed: D1.1 (K), D2.1 (K), LED4.2 (A)
unnamed: LED1.1 (K), R1.1
unnamed: LED2.1 (K), R2.1
unnamed: LED3.1 (K), R3.1
unnamed: LED4.1 (K), R4.1
unnamed: Q1.3 (D), R1.2
unnamed: Q1.1 (G), R6.1, R7.2
unnamed: Q2.3 (D), R2.2
unnamed: Q2.1 (G), R5.1, R10.2
unnamed: R8.2, U1.1 (A)
unnamed: R9.2, U2.1 (A)
OUT_A: C3.1, D1.2 (A), J2.2 (VOUT), MD1.7 (OUT_A), MD1.8 (OUT_A)
OUT_B: C3.2, D2.2 (A), J2.1 (GND), MD1.5 (OUT_B), MD1.6 (OUT_B)
VCC: C1.1, C2.2, J1.2 (VIN), LED1.2 (A), LED2.2 (A), LED3.2 (A), MD1.4 (VCC)
Vcc_U1: C4.1, U1.6 (VDD)
Vcc_U2: C5.1, U2.6 (VDD)

Notes on the sheet:
U1に近づける
U2に近づける

Board: 2 copper layers, 47.0 x 36.0 mm, 29 parts (0 on the bottom side), 22 nets.

## KiCad design lipo-S.V.-simple-v2/lipo-S.V.-simple-v2.kicad_pcb

Parts:
BZ1: Buzzer_12mm; Buzzer_12x9.5RM7.6
C1: 0.33uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
F1: 3557-15; FuseHolder_3557_15
J1: XT60_Female_Horizontal; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J2: XT60_Male_Horizontal; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J3: Conn_01x03_Pin_QI; PinHeader_1x03_P2.54mm_Vertical
LDO1: NJM7805; TO-252-2
LED1: OSL40391_CathodeCommon
LED2: IN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED3: OUT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED4: PWR; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED5: 6S; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED6: 3S; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED7: UPDI; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1, Q2, Q3, Q4, Q5, Q6: BSS138; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8: R220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: R10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW2: Slide SW; SW_CK_JS202011CQN_DPDT_Straight
U1, U2: 74HC595; SOP-16_4.55x10.3mm_P1.27mm
U3: ATtiny202; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: BZ1.1 (+), C2.1, J3.1, LDO1.3 (VOUT), LED4.2 (A), LED5.2 (A), LED7.2 (A), SW2.1 (A), SW2.2 (B), U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.1 (VCC)
A: R1.2, U2.7 (QH)
B: R2.2, U2.6 (QG)
C: R3.2, U2.5 (QF)
D: R4.1, U2.4 (QE)
DP: R8.1, U2.15 (QA)
E: R5.1, U2.3 (QD)
F: R6.2, U2.2 (QC)
G: R7.2, U2.1 (QB)
GND: C1.2, C2.2, J1.1 (GND), J2.1 (GND), J3.3, LDO1.2 (GND), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), R10.2, R11.2, R12.2, R18.2, R20.2, SW2.4 (A), SW2.5 (B), U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE), U3.8 (GND)
unnamed: BZ1.2 (-), Q6.3 (D)
unnamed: C1.1, F1.2, J1.2 (VOUT), LDO1.1 (VIN), LED3.2 (A)
unnamed: LED1.14 (A), R1.1
unnamed: LED1.16 (B), R2.1
unnamed: LED1.13 (C), R3.1
unnamed: LED1.3 (D), R4.2
unnamed: LED1.7 (DP), R8.2
unnamed: LED1.5 (E), R5.2
unnamed: LED1.11 (F), R6.1
unnamed: LED1.15 (G), R7.1
unnamed: LED2.1 (K), R10.1
unnamed: LED3.1 (K), R11.1
unnamed: LED4.1 (K), R12.1
unnamed: LED5.1 (K), R19.1
unnamed: LED6.2 (A), SW2.3 (C)
unnamed: LED6.1 (K), R20.1
unnamed: LED7.1 (K), R21.1
unnamed: Q1.1 (G), U1.7 (QH)
unnamed: Q2.1 (G), U1.6 (QG)
unnamed: Q3.1 (G), U1.5 (QF)
unnamed: Q4.1 (G), U1.4 (QE)
unnamed: Q5.1 (G), U1.3 (QD)
unnamed: R13.2, R14.1
unnamed: R14.2, R15.1
unnamed: R15.2, R16.1
unnamed: R16.2, R17.1
unnamed: U1.9 (QH'), U2.14 (SER)
unnamed: U1.12 (RCLK), U2.12 (RCLK), U3.7 (PA3)
unnamed: U1.14 (SER), U3.4 (PA1)
unnamed: U1.11 (SRCLK), U2.11 (SRCLK), U3.5 (PA2)
UPDI: J3.2, R21.2, U3.6 (~RESET/PA0)
VCC: F1.1, J2.2 (VIN), LED2.2 (A), R13.1
digit1: LED1.1 (Cathode_dig1), Q1.3 (D)
digit2: LED1.2 (Cathode_dig2), Q2.3 (D)
digit3: LED1.6 (Cathode_dig3), Q3.3 (D)
digit4: LED1.8 (Cathode_dig4), Q4.3 (D)
dots: LED1.4 (Cathode_dots), Q5.3 (D)
mode: R19.2, SW2.6 (C), U3.3 (PA7)
mosfet_buzz: Q6.1 (G), U1.2 (QC)
reference: R17.2, R18.1, U3.2 (PA6)

Notes on the sheet:
mode changer
controller
battery voltege separator
buzzer 7-segment display
power supply battery protection

Board: 2 copper layers, 72.0 x 47.5 mm, 45 parts (0 on the bottom side), 50 nets.

## KiCad design MD-IR2302/MD-IR2302.kicad_pcb

Parts:
C1, C3: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C5, C6, C7, C9: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 470uF; CP_Radial_D10.0mm_P5.00mm
C8: 0.47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11: 220uF; CP_Radial_D8.0mm_P3.50mm
D1, D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: XT60_Female_Horizontal; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J2: Conn_01x03_Pin_signal; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3, J4: XH_01x02_Vertical; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: XT60_Male_Horizontal; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
LDO1: NJM7805; TO-252-2
Q1, Q2, Q3, Q4: TK7R4A10PL_TabUp; TO-220-3_Horizontal_TabUp
R1, R2, R3, R4: R47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 910; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9, R10: 4.7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2: IR2302; SOP-8_3.9x4.9mm_P1.27mm
U3, U4: MFSOP6-5_4.4x3.6mm_P1.27mm

Connections:
+5V: C2.2, C5.2, C6.2, C7.2, C9.2, C10.1, D1.2 (A), D2.2 (A), J3.1, LDO1.3 (VOUT), U1.1 (VCC), U1.3 (~SD), U2.1 (VCC), U2.3 (~SD), U3.6 (VCC), U4.6 (VCC)
GND: C2.1, C4.2, C5.1, C6.1, C7.1, C8.2, C9.1, C10.2, C11.2, J3.2, J4.2, J5.1 (GND), LDO1.2 (GND), Q2.3 (S), Q4.3 (S), R2.2, R4.2, U1.4 (COM), U2.4 (COM), U3.4 (GND), U4.4 (GND)
GND1: J2.3, R5.1, R6.2
IN_A: J2.1, U3.1 (Anode)
IN_B: J2.2, U4.1 (Anode)
Motor_Minus: C3.2, J1.1 (GND), Q3.3 (S), Q4.1 (D), R3.2, U2.6 (VS)
Motor_Plus: C1.2, J1.2 (VOUT), Q1.3 (S), Q2.1 (D), R1.2, U1.6 (VS)
unnamed: C1.1, D1.1 (K), U1.8 (VB)
unnamed: C3.1, D2.1 (K), U2.8 (VB)
unnamed: Q1.2 (G), R1.1, R7.2
unnamed: Q2.2 (G), R2.1, R8.2
unnamed: Q3.2 (G), R3.1, R9.1
unnamed: Q4.2 (G), R4.1, R10.1
unnamed: R5.2, U3.3 (Cathode)
unnamed: R6.1, U4.3 (Cathode)
U1_HO: R7.1, U1.7 (HO)
U1_IN: U1.2 (IN), U3.5 (Vout)
U1_LO: R8.1, U1.5 (LO)
U2_HO: R9.2, U2.7 (HO)
U2_IN: U2.2 (IN), U4.5 (Vout)
U2_LO: R10.2, U2.5 (LO)
VCC: C4.1, C8.1, C11.1, J4.1, J5.2 (VIN), LDO1.1 (VIN), Q1.1 (D), Q3.1 (D)

Notes on the sheet:
ファン用電源

Board: 2 copper layers, 95.0 x 72.0 mm, 37 parts (2 on the bottom side), 22 nets.

File MD-IR2302/parts_list.md:

リファレンス|値|数量|リンク|備考
---|---|---|---|---
C1,C3|10uF|2|[秋月](https://akizukidenshi.com/catalog/g/g113336/)|
C2,C5,C6,C7,C9|0.1uF|5|[秋月](https://akizukidenshi.com/catalog/g/g111384/)|
C4|470uF|1|[秋月](https://akizukidenshi.com/catalog/g/g102719/)|
C8|0.47uF|1|[秋月](https://akizukidenshi.com/catalog/g/g117142/)|
C10,C11|220uF|2|[秋月](https://akizukidenshi.com/catalog/g/g102718/)|実装しない
D1,D2|1N4148|2|[秋月](https://akizukidenshi.com/catalog/g/g100941/)|
J1|XT60メス基板実装用|1|[秋月](https://akizukidenshi.com/catalog/g/g118155/)|
J2|XH3ピン|1|[秋月](https://akizukidenshi.com/catalog/g/g112248/)|
J3,J4|XH2ピン|2|[秋月](https://akizukidenshi.com/catalog/g/g112247/)|実装しない
J5|XT60オス基板実装用|1|[秋月](https://akizukidenshi.com/catalog/g/g118156/)|
LDO1|NJM7805|1|[秋月](https://akizukidenshi.com/catalog/g/g111237/)|
Q1,Q2,Q3,Q4|TK7R4A10PL|4|[秋月](https://akizukidenshi.com/catalog/g/g116488/)|
R1,R2,R3,R4|47kΩ|4|千石地下一階にて入手可能|1608サイズ
R5,R6|910Ω|2|千石地下一階にて入手可能|1608サイズ
R7,R8,R9,R10|4.7Ω|4|千石地下一階にて入手可能|1608サイズ、抵抗ない時はショートでも可
U1,U2|IR2302|2|[秋月](https://akizukidenshi.com/catalog/g/g115656/)|
U3,U4|TLP2361|2|[秋月](https://akizukidenshi.com/catalog/g/g111004/)|

## Commit log

2025-08-08 nhkrcでのファイルを移動
2025-09-07 Fix formatting of lipo-S.V.-simple-v2 entry in README
2025-09-07 Fix voltage rating description in README.md
2025-09-10 edit gitignore
2025-09-10 v0.1
2025-09-26 フォトカプラ追加中
2025-09-26 ライブラリの項目追加。ライブラリ自体は未作成。
2025-09-26 v0.2作成
